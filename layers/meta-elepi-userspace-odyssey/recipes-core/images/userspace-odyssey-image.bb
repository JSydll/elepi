
inherit elepi-adventure-image

QUESTS_LIST = " \
    hear-the-kernel-talking \
    let-me-sysfs-this-for-you \
    below-the-shadows \
"