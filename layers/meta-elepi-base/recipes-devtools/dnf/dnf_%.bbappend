FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-conf-skip-diskspace-check-for-squashfs.patch"

